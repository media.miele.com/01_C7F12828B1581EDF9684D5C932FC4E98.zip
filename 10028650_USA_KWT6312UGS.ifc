Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: cbeebb05-6048-471f-a075-e618a2f23f4a, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-06T09:37:20+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 10028650_USA_KWT6312UGS:36631200_USA_10028650_KWT6312UGS, (2)
In: Default
Type - Material: Výchozí Nový materiál(1), z_Miele_Design_Steel_Chrom, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel, z_Miele_Design_OBSW, Default New Material, z_Miele_Design_Glass, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 597 mm; Height: 820 mm; Depth: 577 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 36631200_USA_10028650_KWT6312UGS; sets with these values: 2

# IfcDistributionPort, Port_361815_1
Description: Flow; FlowDirection: SOURCEANDSINK
